# IAR project at91sam7l-ek.ewp, settings and files
configuration HP12C (ARM, debug)
  General.OGChipSelectEditMenu: at91sam7l128 Atmel at91sam7l128
  ICCARM.CCDefines: at91sam7l128; flash; _ARM_; C12
  ICCARM.CCDiagSuppress: Pe826,Pe1375
  ICCARM.CCIncludePath2: ..\src; ..\..; ..\..\at91lib; ..\..\at91lib\boards\at91sam7l-ek
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: at91sam7l128; flash
  AARM.AUserIncludes: ..\..\..\at91lib; ..\..\..\at91lib\peripherals; ..\..\..\at91lib\boards\at91sam7l-ek
  OBJCOPY.OOCOutputFile: at91sam7l128_at91sam7l128_flash.srec
  prebuild: "../../CreateDate.exe" "../../build.cpp" hp12c.h
  postbuild: objcopy -O binary "$TARGET_BPATH$.out" "$TARGET_BPATH$.bin"
  ILINK.IlinkOutputFile: HP12C+.out
  ILINK.IlinkIcfFile: ..\..\at91lib\boards\at91sam7l-ek\at91sam7l128\flash.icf
  ILINK.IlinkProgramEntryLabel: resetHandler
  group atmel config
    ../../resources/: at91sam7l-ek-flash.mac
    ../../at91lib/boards/at91sam7l-ek/at91sam7l128/: AT91SAM7L128.h flash.icf
    ../../at91lib/boards/at91sam7l-ek/: board.h board_cstartup_iar.s board_lowlevel.c
  group system
    ../src/: autoTests.c dbgu.c dcboperations.s keyborad.c lcd.c main.c rtc.c timers.cpp
    ../../: build.cpp graphics.cpp hp12C.cpp system.cpp
  group system/include
    ../src/: autotests.h dbgu.h keyboard.h lcd.h main.h rtc.h timers.h
    ../../: graphics.h hp12c.h system.h
